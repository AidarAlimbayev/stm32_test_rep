# Keil uVision project nucleo_button.uvprojx, settings and files
target Target 1 (6150000::V6.15::ARMCLANG)
  device: STM32F302R8Tx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: nucleo_button
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32F302R8Tx/STCubeGenerated/Src/: main.c stm32f3xx_it.c
    ./RTE/Device/STM32F302R8Tx/STCubeGenerated/Inc/: stm32f3xx_it.h
software components: CMSIS:CORE 5.4.0, Device:STM32Cube HAL 1.9.0, Board Support:Buttons 0.9.0, Board Support:LED 0.9.0
